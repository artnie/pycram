Commit message: dump educon prep

File: resources/apartment_no_walls.urdf (robot description, URDF)
Before this commit: robot apartment, 109 links, 107 joints
Joints:
- added joint wardrobe_joint: type fixed, parent furnitures_root, child wardrobe, origin xyz=9.7082 -0.6331 0.0 rpy=0 0 0
